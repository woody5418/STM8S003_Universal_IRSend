# IAR project Backup (2) of STM8S_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_Demo.hex
  ILINK.IlinkOutputFile: STM8S_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWlib/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group USER
    ../USER/: adc.c delay.c flash_eeprom.c key.c led.c main.c stm8s_it.c sysclock.c tim1.c tim2.c uart.c
